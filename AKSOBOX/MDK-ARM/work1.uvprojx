# Keil uVision project work1.uvprojx, settings and files
target work1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L475VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: work1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: USE_HAL_DRIVER,STM32L475xx
  c include: ../Core/Inc;             ../Drivers/STM32L4xx_HAL_Driver/Inc;             ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;             ../Drivers/CMSIS/Device/ST/STM32L4xx/Include;             ../Drivers/CMSIS/Include;             ..\Core\iot;             ..\Core\cjson;             ..\Core\Driver;        ../Middlewares/Third_Party/FreeRTOS/Source/include;        ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;        ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Driver
    ../Core/Driver/: AHT10.c AHT10.h esp8266.c esp8266.h font.h lcd.c lcd.h str.c str.h stmflash.c stmflash.h w25qxx.c w25qxx.h ds1302.c ds1302.h
  group iot
    ../Core/iot/: iot_aliyun.c iot_aliyun.h deel_mqtt.h deel_mqtt.c iot_emqx.c iot_emqx.h mqttkit.h mqttkit.c
  group Application/User/Core
    ../Core/Src/: malloc.c main.c gpio.c freertos.c quadspi.c spi.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c
    ../Core/Inc/: main.h
  group cjson
    ../Core/cjson/: cJSON.c cJSON.h
  group Application/MDK-ARM
    ./: startup_stm32l475xx.s
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_qspi.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group HAMC
    ../Core/HMAC/: utils_hmac.c utils_hmac.h utils_md5.c utils_md5.h utils_sha1.c utils_sha1.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 5.6.0
